## firmware/boards/clink/clink_w59/board.yml
```yaml
board:
  name: clink_w59
  full_name: CLINK W59 (KKM W59, nRF52832)
  socs:
    - name: nrf52832
```
